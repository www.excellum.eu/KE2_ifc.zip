Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-12-23T11:55:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161117_1200(x64) - Exporter 17.0.1099.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 23 11:55:06 2016 * Host: WITAS2 * Database: C:\Users\WITAS_~1\AppData\Local\Temp\{EE4FCE57-0745-4CBA-A0E7-896D52C1D821}\ifc * Database version: 5507 * Database creation date: Fri Dec 23 11:55:05 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 23 11:55:05 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 23 11:55:05 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: KE21 6N 230 ATEX1, Dummy:KE21 6N 230 ATEX1:210646
In: Level 1
Type - Material: BE Armatuur, BERSnl_glas lamp
Type - Constraints - Default Elevation: 1000 mm; WT_H Behuizing: Standaard; WT_H Bevestiging: Geen; WT_H Breedte: 80 mm; WT_H Coarse geometrie: Standaard; WT_H Halve breedte negatief: -40 mm; WT_H Halve lengte negatief: -211.5 mm; WT_H Hoogte: 149 mm; WT_H Lengte: 423 mm; WT_H Lichtbron_breedte: 72 mm; WT_H Lichtbron_lengte: 380.7 mm; WT_H Opbouw: yes; WT_H Pendel horizontale armatuurmontage: no; WT_H Referentie: Opbouw; WT_H Symbool wand hoogte: 149 mm; WT_H Symbool wand lengte: 423 mm; WT_H Uitsteek: 0 mm
Type - Dimensions - BE_G Breedte: 80 mm; BE_G Hoogte: 149 mm; BE_G Lengte: 423 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 0 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 0 W
Type - Graphics - WT_V Symbool plafond: rectangular - luminaire - led; WT_V Symbool wand: none_gen
Type - Identity Data - BE_I Bestelcode: KE21/6N-230-ATEX1; Manufacturer: ETAP; Model: KE2; Type Comments: Noodverlichtingsarmatuur; Type Name: KE21 6N 230 ATEX1; URL: http://www.etaplighting.com/level2.aspx?seq=86&seqpicture=2227&name=Lighting&LangType=1033; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - BE_G Materiaal/Kleur: BE Armatuur; WT_V Lichtbron_materiaal: BERSnl_glas lamp; WT_V Reflector_materiaal: BERSnl_glas lamp
Type - Model Properties - WT_I Armatuurrendement: 0; WT_I Autonomie: -; WT_I Batterij type: -; WT_I Kleur: RAL9018; WT_I Maatschets catalogus: -; WT_I Montage: opbouw; WT_I Optiek: diffusor; WT_I Specifieke uitvoering: -; WT_I Werking: niet perm.; WT_I Zelftest: zonder
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Noodverlichtingsarmatuur_ETAP KE2 - lichtbron: KE21_6N-230-ATEX1_ELZONDER; WT_I Aantal lampen: 0; WT_I Lamptype: Lamp Led; WT_I Lichtstroom armatuur: 600 lm; WT_I Vermogen lamp: 0 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: KE21 6N 230 ATEX1
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Offset lichtbron: 124 mm
Construction - WT_V Pendelhoogte: 150 mm
Dimensions - Area: 0.303892 m2; Volume: 0.014072 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-0 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 3
Other - Family: Dummy: KE21 6N 230 ATEX1; Family and Type: Dummy: KE21 6N 230 ATEX1; Schedule Level: Level: Level 1; Type: Dummy: KE21 6N 230 ATEX1; Type Id: Dummy: KE21 6N 230 ATEX1
Phasing - Phase Created: 64113
